SRC_URI_remove = "http://www.hwaci.com/sw/sqlite/sqlite-${PV}.tar.gz"
SRC_URI_append = "https://storage.googleapis.com/oaklabs-public/sqlite-${PV}.tar.gz"
SRC_URI[md5sum] = "838dbac20b56d2c4292e98848505a05b"    
SRC_URI[sha256sum] = "3f35ebfb67867fb5b583a03e480f900206af637efe7179b32294a6a0cf806f37" 
